RDEPENDS:${PN}:remove = "connman connman-tools connman-tests connman-client"