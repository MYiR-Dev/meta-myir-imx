FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-FEAT-change-default-env-file-to-etc-u-boot-imx-initi.patch"

