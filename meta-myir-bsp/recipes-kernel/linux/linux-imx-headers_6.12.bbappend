# Use MYIR kernel fork (same source as linux-imx) since nxp-imx is slow/unreachable
LINUX_IMX_SRC = "git://github.com/MYD-JMX95/myir-imx-linux.git;protocol=https;branch=develop_6.12.49"
SRCREV = "27de3d1c80ed22795a09732fb3be96c4c0a0c31d"
