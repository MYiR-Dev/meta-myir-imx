# append new URL to SRC_URI

SRC_URI="git://github.com/nxp-imx/imx-lib.git;protocol=https;branch=master"