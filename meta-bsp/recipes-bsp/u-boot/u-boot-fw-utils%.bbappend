require u-boot-common.inc
