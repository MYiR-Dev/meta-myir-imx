SRC_URI = "git://bgithub.xyz/google/googletest.git;branch=main;protocol=https"