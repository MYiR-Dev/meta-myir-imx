SRC_URI = "git://bgithub.xyz/intel/${BPN};branch=main;protocol=https"