VALGRIND_aarch64 = "valgrind"
RDEPENDS_${PN}_remove = "valgrind blktrace "
