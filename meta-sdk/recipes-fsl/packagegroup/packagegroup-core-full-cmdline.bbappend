RDEPENDS_packagegroup-core-full-cmdline-extended_remove = " iputils"
RDEPENDS_packagegroup-core-full-cmdline-multiuser_remove = "gzip"
RDEPENDS_packagegroup-core-full-cmdline-utils_remove = "cpio util-linux"
