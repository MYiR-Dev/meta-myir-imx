QT6_IMAGE_INSTALL_QUICK3D:myd-js8mpq = "qtquick3d"
